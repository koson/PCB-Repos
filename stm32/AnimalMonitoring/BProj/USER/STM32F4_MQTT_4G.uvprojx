# Keil uVision project STM32F4_MQTT_4G.uvprojx, settings and files
target STM32F4_M8266WIFI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\MQTTPacket\src;..\MQTTPacket\ops;.\RTE;.\RTE\RTOS;..\HARDWARE;..\EC25;..\My_lib;..\bsp_device\HELLO_LED;..\HARDWARE\PWR;..\MALLOC;..\HARDWARE\SDIO;..\FATFS\src;..\FATFS\exfuns;..\FATFS\draft;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\USMART;..\USB\USB_APP;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_HOST_Library\Core\inc;..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\HARDWARE\TIMER;..\CJSON;..\HARDWARE\STMFLASH;..\HARDWARE\MAX44009;..\HARDWARE\SHT;..\HARDWARE\ms5611;..\HARDWARE\IIC;..\HARDWARE\SPI;..\HARDWARE\SESR;..\HARDWARE\RTC;..\HARDWARE\IWDG;..\MD5;..\Queue;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\USART3;..\HARDWARE\ADC;..\HARDWARE\RNG;..\HARDWARE\USART2;..\HARDWARE\BATTERY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c system_stm32f4xx.c os_include.h usertypedef.h
  group My_lib
    ../My_lib/: MyFunction_C.c MyFunction_C.h
  group EC25
    ../EC25/: ec25.c ec25.h UART_TCPbuff.c UART_TCPbuff.h
  group MQTTOPS
    ../MQTTPacket/ops/: mqttApp.c mqttBase.c mqttTransport.c
  group HARDWARE
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/IIC/: myiic_max44009.c myiic_sht20.c
    ../HARDWARE/MAX44009/: max44009.c
    ../HARDWARE/SHT/: SHT2x.c
    ../HARDWARE/SESR/: sensor.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/ms5611/: ms5611.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/PWR/: power.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USART3/: usart3.c usart3.h
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/RNG/: rng.c
    ../HARDWARE/USART2/: usart2.h usart2.c
    ../HARDWARE/BATTERY/: battery.c battery.h
  group MQTTLIB
    ../MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_pwr.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_rtc.c stm32f4xx_iwdg.c stm32f4xx_adc.c stm32f4xx_rng.c
  group MALLOC
    ../MALLOC/: malloc.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/option/: unicode.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST
    ../USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbh_usr.c usb_app.c
  group CJSON
    ../CJSON/: cJSON.c
  group Queue
    ../Queue/: Queue.c
software components: RTOS:uC/OS Common 1.0.0, RTOS:uC/OS Kernel 1.0.0
